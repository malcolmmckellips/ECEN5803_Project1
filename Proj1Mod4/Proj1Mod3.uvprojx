# Keil uVision project Proj1Mod3.uvprojx, settings and files
target Proj1Mod3 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: CPUTYPE("Cortex-M0+")
  output: Proj1Mod3 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=7 wLevel=2
  c define: DEVICE_ANALOGIN=1 DEVICE_STDIO_MESSAGES=1 DEVICE_I2CSLAVE=1 TARGET_M0P TARGET_LIKE_CORTEX_M0 DEVICE_SPI=1 MBED_BUILD_TIMESTAMP=1632099101.991984 __MBED_CMSIS_RTOS_CM __CMSIS_RTOS DEVICE_PWMOUT=1 DEVICE_INTERRUPTIN=1 MBED_ROM_START=0x0 DEVICE_SERIAL=1 DEVICE_SLEEP=1 TARGET_FF_ARDUINO TOOLCHAIN_ARM DEVICE_I2C=1 MBED_RAM_SIZE=0x4000 DEVICE_PORTINOUT=1 __CORTEX_M0PLUS __MBED__=1 TOOLCHAIN_ARM_STD TOOLCHAIN_ARMC6 __ASSERT_MSG DEVICE_SEMIHOST=1 TARGET_Freescale TARGET_LIKE_MBED DEVICE_USTICKER=1 MBED_RAM_START=0x1ffff000 ARM_MATH_CM0PLUS DEVICE_PORTOUT=1 TARGET_KL25Z DEVICE_PORTIN=1 DEVICE_SPISLAVE=1 TARGET_CORTEX MULADDC_CANNOT_USE_R7 MBED_TRAP_ERRORS_ENABLED=1 MBED_ROM_SIZE=0x20000 TARGET_NAME=KL25Z DEVICE_ANALOGOUT=1 TARGET_RELEASE TARGET_CORTEX_M MBED_MINIMAL_PRINTF TARGET_KLXX
  c misc: --no_rtti --cpu=Cortex-M0plus -c --split_sections --no_depend_system_headers --md --gnu --apcs=interwork --preinclude=mbed_config.h
  c include: ;/usr/src/mbed-sdk;mbed;mbed/TARGET_KL25Z;mbed/TARGET_KL25Z/TARGET_Freescale;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z;mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device;mbed/drivers;mbed/hal;mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-DARM_MATH_CM0PLUS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M0PLUS,-D__CMSIS_RTOS
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/MKL25Z4.sct
  link misc: --predefine="-DMBED_BOOT_STACK_SIZE=4096" --predefine="-DXIP_ENABLE=0" --predefine="-DMBED_ROM_SIZE=0x20000" --any_contingency --legacyalign --show_full_path --cpu=Cortex-M0plus --predefine="-DMBED_RAM_START=0x1ffff000" --inline --keep=os_cb_sections --predefine="-DMBED_RAM_SIZE=0x4000" --predefine="-DMBED_ROM_START=0x0"
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o i2c_api.o mbed.ar mbed_board.o mbed_overrides.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o retarget.o rtc_api.o serial_api.o sleep.o spi_api.o startup_MKL25Z4.o sys.o system_MKL25Z4.o us_ticker.o
    mbed/TARGET_KL25Z/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_assert.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_stats.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/: clk_freqs.h gpio_object.h objects.h PeripheralPins.h PortNames.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/device/: cmsis.h cmsis_nvic.h MKL25Z4.h system_MKL25Z4.h
    mbed/TARGET_KL25Z/TARGET_Freescale/TARGET_KLXX/TARGET_KL25Z/: device.h PeripheralNames.h PinNames.h
    mbed/: mbed.h
    mbed/TARGET_KL25Z/TARGET_Freescale/: mbed_rtx.h
  group Proj1Mod3
    ./: main.cpp mbed_config.h Monitor.cpp shared.h timer0.cpp UART_poll.cpp
